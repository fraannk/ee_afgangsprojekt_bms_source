<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bms.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>led_blinky</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>led_blinky</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>led_blinky</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>led_blinky</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
