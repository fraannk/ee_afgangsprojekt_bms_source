# IAR project bms.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC804M101 NXP LPC804M101
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC804; CPU_LPC804M101JDH24
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; board/src; doc; drivers; startup; utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: led_blinky.out
  ILINK.IlinkIcfFile: LPC804_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_LPC804; CPU_LPC804M101JDH24
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    board/: pin_mux.c pin_mux.h
  group board/src
    board/src/: board.c board.h clock_config.c clock_config.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h fsl_device_registers.h LPC804.h LPC804_features.h mpu_armv7.h mpu_armv8.h system_LPC804.c system_LPC804.h
  group drivers
    drivers/: fsl_acomp.c fsl_acomp.h fsl_adc.c fsl_adc.h fsl_capt.c fsl_capt.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_ctimer.c fsl_ctimer.h fsl_dac.c fsl_dac.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_iocon.h fsl_mrt.c fsl_mrt.h fsl_pint.c fsl_pint.h fsl_plu.c fsl_plu.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi.h fsl_swm.c fsl_swm.h fsl_swm_connections.h fsl_syscon.c fsl_syscon.h fsl_syscon_connections.h fsl_systick.c fsl_systick.h fsl_usart.c fsl_usart.h fsl_wkt.c fsl_wkt.h fsl_wwdt.c fsl_wwdt.h rom_api.h
  group source
    source/: main.c
  group startup
    startup/: startup_LPC804.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
